# Repository Yoshiharu1962/ForestDesign-Mori-1

File README.md:

# 概要
Arduino UNOの外形で、マイコンにESP32-S3 WROOM-1 を実装したボードコンピューター
GPIOは全て+3.3V
Lチカ用にNeoPixelを搭載。 
NeoPixelは5Vを供給。パルスも5Vレベルに変換。更にNeoPixel信号を外部に出せる構成となっている。
更に、オンボードでOLEDが搭載可能にするコネクタランドも用意した。

# 名称
「森壱式」とした。本家「Arduino UNO」がイタリア語であることから、本家にリスペクトする意味も込めて完全日本語として名付けた。

# 開発へのいきさつ
以前よりESP32-S3を業務等で使用しており、その便利さや処理速度等のパワーを知っていた。
本家より「Arduino UNO R4」が発表となり、それで使用されるMCUがArmコア、そして通信用にESP32-S3が採用されているのを知った。
この時、ESP32-S3だけでも十分過ぎるを使えるんじゃね？と感想を抱いたのが開発のきっかけである。

# 特徴
Lチカをより楽しむために、NeoPixelへのドライブ能力を強化している。またオンボード上にNeoPixelを1個増設している。
ESP32-S3 WROOM-1 は 3.3V仕様であるが、NeoPixelのデータ信号で使用する「G38」を+5Vにレベル変換しオンボードのNeoPixelを駆動するほか、NPXコネクタにも5Vで出力している。さらに、5V電源も750mAまで出力可能な仕様としている。
その他、市販のOLEDを直接実装可能なコネクタスペース、Groveコネクタ実装可能なコネクタスペースを設けている。
GPIOはNeoPixel専用出力を除き、全て3.3Vである。

# 外観
部品面（イメージは改一のもの）

ハンダ面（イメージは改一のもの）

# 搭載マイコンモジュール
ESP32-S3-WROOM-1-N16R8 を搭載。
開発環境はESP32-S3 WROOM-1を参照のこと。
Arduino IDEで開発可能。

# 外部インターフェイス
- Grove互換 I2Cコネクタ装備。 使用電圧は+3.3V。
- NeoPixel用出力コネクタ搭載。5V MAX750mAまで本ボードのみで駆動できます。
# pin配置図

# 回路図

MORI_ICHI_1_SCH.pdf

## KiCad design MORI_ICHI.kicad_pcb

Parts:
C1, C2, C3, C4: CL21A226MAQNNNE; C_0805_2012Metric; JLCPCB Part # C45783
C5, C6: CL21A106KAYNNNE; C_0805_2012Metric; JLCPCB Part # C15850
C7, C8: CC0805KRX7R9BB104; C_0805_2012Metric; JLCPCB Part # C49678
C9, C10: CC0603KRX7R9BB104; C_0603_1608Metric; JLCPCB Part # C14663
C11, C13: CL10A106MA8NRNC; C_0603_1608Metric; JLCPCB Part # C96446
C12, C14: CC0603KRX7R9BB105; C_0603_1608Metric; JLCPCB Part # C559769
D1, D2, D3: LESD5D5.0CT1G; D_SOD-523; JLCPCB Part # C5246195
D4: 1N5819HW-7-F; D_SOD-123; JLCPCB Part # C82544
D5: PMEG6020ER; D_SOD-123F; JLCPCB Part # C52146084
D6: WS2812B-V5/W; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; JLCPCB Part # C2874885
D17: XL-1608UBC-04; LED_0603_1608Metric; JLCPCB Part # C965807
F1: MF-MSMF075-2; Fuse_1812_4532Metric; JLCPCB Part # C84140
G19, G20, G41, G42, G45, G46, G47, G48: PAD; TestPoint_Pad_D1.0mm
J1: Power; PinSocket_1x08_P2.54mm_Vertical
J2: Digital/PWM; PinSocket_1x10_P2.54mm_Vertical
J3: Analog; PinSocket_1x06_P2.54mm_Vertical
J4: Digital/PWM; PinSocket_1x08_P2.54mm_Vertical
J5: KH-TYPE-C-16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; JLCPCB Part # C709357
J6: Grove; NS-Tech_Grove_1x04_P2mm_Vertical
J7: MJ-179PH; BarrelJack_Horizontal
J8: FH-1x3SG/RH; PinSocket_1x03_P2.54mm_Vertical
J9: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
Q1, Q2: L8050QLT1G; SOT-23; JLCPCB Part # C49581
R1, R2, R10, R13: 0603WAF1002T5E; R_0603_1608Metric; JLCPCB Part # C25804
R3, R4, R5, R8: 0603WAF0000T5E; R_0603_1608Metric; JLCPCB Part # C21189
R6, R7: 0603WAF5101T5E; R_0603_1608Metric; JLCPCB Part # C23186
R9: 0603WAF1001T5E; R_0603_1608Metric; JLCPCB Part # C21190
R11: FRC0603F2212TS; R_0603_1608Metric; JLCPCB Part # C2960862
R12: 0603WAF4752T5E; R_0603_1608Metric; JLCPCB Part # C23061
R18, R19: 0805W8F4701T5E; R_0805_2012Metric; JLCPCB Part # C17673
R71: 0603WAF1202T5E; R_0603_1608Metric; JLCPCB Part # C22790
R72, R73: 0603WAF2202T5E; R_0603_1608Metric; JLCPCB Part # C31850
SW1, SW2: TS-1187A-B-A-B; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
TP1, TP2: RH-5019; TestPoint_Keystone_5019_Miniature; JLCPCB Part # C5199800
U1: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1; JLCPCB Part # C2913202
U2: CP2102N-A02-GQFN28R; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; JLCPCB Part # C964632
U3: L7805CDT-TR; TO-252-2; JLCPCB Part # C310413
U4: SGM2212-3.3XKC3G/TR; SOT-223-3_TabPin2; JLCPCB Part # C3294699
U5: 74HCT14PW,118; TSSOP-14_4.4x5mm_P0.65mm; JLCPCB Part # C5968

Connections:
+3V3: C6.1, C8.1, C10.1, C11.1, C13.2, J1.4, J6.2, J9.3, R8.2, R9.1, R13.1, R18.2, R19.2, R72.1, R73.1, U2.6 (VDD), U2.7 (VREGIN), U4.2 (VO)
+5V: C3.1, C4.1, C5.1, C7.1, C9.1, D6.1 (VDD), F1.2, J1.5, J8.1, R71.1, TP2.1 (1_1), U4.3 (VI), U5.14 (VCC)
/+5VF: D4.1 (K), F1.1, U3.3 (OUT)
/CC1: J5.A5 (CC1), R6.2
/CC2: J5.B5 (CC2), R7.2
/ESP_3V3: R8.1, U1.2 (3V3)
/G0: R4.1, SW1.2, U1.27 (IO0)
/G1: J3.1, U1.39 (IO1)
/G2: R72.2, U1.38 (IO2)
/G3: R73.2, U1.15 (IO3)
/G4: J3.2, U1.4 (IO4)
/G5: J3.3, U1.5 (IO5)
/G6: J3.4, U1.6 (IO6)
/G7: J3.5, U1.7 (IO7)
/G8: J3.6, U1.12 (IO8)
/G11: J2.5, U1.19 (IO11)
/G12: J2.6, U1.20 (IO12)
/G13: J2.7, U1.21 (IO13)
/G14: J2.8, U1.22 (IO14)
/G15: J2.9, U1.8 (IO15)
/G16: J2.10, U1.9 (IO16)
/G17: J4.1, U1.10 (IO17)
/G18: J4.2, U1.11 (IO18)
/G19: G19.1 (1_1), U1.13 (USB_D-)
/G20: G20.1 (1_1), U1.14 (USB_D+)
/G21: J4.3, U1.23 (IO21)
/G35: J4.4, U1.28 (IO35)
/G36: J4.5, U1.29 (IO36)
/G37: J4.6, U1.30 (IO37)
/G38: R5.2, U1.31 (IO38)
/G39: J4.7, U1.32 (IO39)
/G40: J4.8, U1.33 (IO40)
/G41: G41.1 (1_1), U1.34 (IO41)
/G42: G42.1 (1_1), U1.35 (IO42)
/G45: G45.1 (1_1), U1.26 (IO45)
/G46: G46.1 (1_1), U1.16 (IO46)
/G47: G47.1 (1_1), U1.24 (IO47)
/G48: G48.1 (1_1), U1.25 (IO48)
/SCL: J2.1, J6.4, J9.2, R19.1, U1.18 (IO10)
/SDA: J2.2, J6.3, J9.1, R18.1, U1.17 (IO9)
/U1RXD: U1.36 (RXD0), U2.26 (TXD)
/U1TXD: U1.37 (TXD0), U2.25 (RXD)
/USB_DN: D1.2 (A2), J5.A7 (D-), J5.B7 (D-), U2.5 (D-)
/USB_DP: D2.2 (A2), J5.A6 (D+), J5.B6 (D+), U2.4 (D+)
/~RESET: C14.2, J1.3, R3.1, R13.2, SW2.2, U1.3 (EN)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, D1.1 (A1), D2.1 (A1), D3.1 (A1), D6.3 (VSS), D17.1 (K), J1.6, J1.7, J2.4, J5.A1 (GND), J5.A12 (GND), J5.B1 (GND), J5.B12 (GND), J5.SH (SHIELD), J6.1, J7.2 (Ext), J8.3, J9.4, R6.1, R7.1, R10.1, R12.1, SW1.1, SW2.1, TP1.1 (1_1), U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.3 (GND), U2.29 (GND), U3.2 (GND), U4.1 (GND), U5.5, U5.7 (GND), U5.9, U5.11, U5.13
unnamed: C1.2, C2.1
unnamed: D5.2 (A), J7.1 (In)
unnamed: D6.4 (DIN), U5.4
unnamed: D6.2 (DOUT), J8.2
unnamed: D17.2 (A), R71.2
unnamed: Q1.1 (B), R1.1
unnamed: Q1.3 (C), R3.2
unnamed: Q1.2 (E), R2.2, U2.24 (~RTS)
unnamed: Q2.1 (B), R2.1
unnamed: Q2.3 (C), R4.2
unnamed: Q2.2 (E), R1.2, U2.28 (~DTR)
unnamed: R5.1, U5.1
unnamed: C12.1, R11.1, R12.2, U2.8 (VBUS)
unnamed: R9.2, U2.9 (~RST)
unnamed: R10.2, U2.11 (~SUSPEND)
unnamed: U5.2, U5.3
VBUS: D3.2 (A2), D4.2 (A), J5.A4 (VBUS), J5.A9 (VBUS), J5.B4 (VBUS), J5.B9 (VBUS), R11.2
VCC: C1.1, D5.1 (K), J1.8, U3.1 (IN)

Notes on the sheet:
SDA
NeoPixel回路へ3.3V→5V変換
G9 SDA
改一で10kΩと1μF追加
G10 SCL
RMT
G10
SCL

Board: 2 copper layers, 68.6 x 53.3 mm, 72 parts (3 on the bottom side), 64 nets.

Other parts of the board:
MH1, MH2, MH3, MH4: MountingHole_3.2mm
